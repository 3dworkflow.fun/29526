# Autodesk Inventor assembly: RUBBERBANDGUN
## iProperties
Created: 2010-11
Part Number: RUBBERBANDGUN
Document SubType Name: Assembly
Designer: ROBERT
Author: ROBERT
