# Autodesk Inventor part: BARREL
## iProperties
Created: 2010-11
Part Number: BARREL
Document SubType Name: Modeling
Designer: ROBERT
Density: 1 g/cm^3
Author: ROBERT
## Feature names
1. Extrusion1
